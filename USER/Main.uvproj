# Keil uVision project Main.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\inc;..\HARDWARE\inc;..\INCLUDING;..\FATFS\src;..\GUI;..\STM32F10x_FWLib\inc;..\tqOS;..\util;..\FingerPrint
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./: startup_stm32f10x_hd.s
  group USER
    ./: Main.c
    ../: readme.txt
  group FWlib
    ../STM32F10x_FWLib/src/: stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_iwdg.c stm32f10x_pwr.c
  group SYSTEM
    ../SYSTEM/src/: SYS.c GPIO.c USART.c DELAY.c FSMC.c SPI.c PWM.c TIM.c
  group HARDWARE
    ../HARDWARE/src/: ws2812.c
  group FingerPrint
    ../FingerPrint/: Example.c Protocol.c Uartport.c
  group Util
    ../util/: util_queue.c
